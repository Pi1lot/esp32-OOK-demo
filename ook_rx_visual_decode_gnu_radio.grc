options:
  parameters:
    description: Recepteur OOK visuel pour le montage pedagogique ESP32 -> Nooelec. Waterfall + vue temporelle de l'enveloppe demodulee.
    generate_options: qt_gui
    id: ook_rx_visual
    output_language: python
    title: Récepteur OOK - Waterfall, enveloppe et message décodé
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '27018000'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: Gain RTL-SDR
    start: '0'
    step: '1'
    stop: '49'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '4000'
    max_iter: '4000'
    scale: '0.00025'
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '50000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"numchan=1"'
    bb_gain0: '20'
    bw0: '200000'
    freq0: center_freq
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '20'
    num_mboards: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: Enveloppe OOK
    name: Enveloppe (presence/absence porteuse)
    size: '2000'
    srate: samp_rate
    type: float
    ymin: '0'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    name: Waterfall - porteuse autour de center_freq
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          """Seuil adaptatif, reconstruction temporelle et décodage ASCII OOK."""
          def __init__(self, samp_rate=2000000, bit_duration=0.300):
              gr.sync_block.__init__(self, name="OOK ASCII decoder", in_sig=[np.float32], out_sig=None)
              self.message_port_register_out(pmt.intern("msg"))
              self.samp_rate = float(samp_rate)
              self.bit_duration = float(bit_duration)
              self.oversample = 5
              # Une mesure toutes les 1/5 de durée de bit, comme dans jouuuj.py.
              self.samples_per_measure = max(1, int(self.samp_rate * self.bit_duration / self.oversample))
              self.counter = 0
              self.level_history = []
              self.raw_symbols = []
              self.last_text = ""
              self.preamble = "1010101011"

          def _reconstruct_bits(self):
              if not self.raw_symbols:
                  return ""
              runs = []
              current = self.raw_symbols[0]
              run_len = 1
              for symbol in self.raw_symbols[1:]:
                  if symbol == current:
                      run_len += 1
                  else:
                      runs.append((current, run_len))
                      current, run_len = symbol, 1
              runs.append((current, run_len))
              bits = []
              for symbol, length in runs:
                  n_bits = max(1, int(round(length / self.oversample)))
                  bits.append(symbol * n_bits)
              return "".join(bits)

          def _decode(self, bitstream):
              idx = bitstream.find(self.preamble)
              if idx < 0:
                  return ""
              payload = bitstream[idx + len(self.preamble):]
              chars = []
              # Le flux peut se terminer au milieu d'un octet : on ignore ces bits.
              for j in range(0, len(payload) - 7, 8):
                  byte_bits = payload[j:j+8]
                  value = int(byte_bits, 2)
                  if 32 <= value <= 126:
                      chars.append(chr(value))
                  else:
                      break
              return "".join(chars)

          def work(self, input_items, output_items):
              for value in input_items[0]:
                  self.counter += 1
                  if self.counter < self.samples_per_measure:
                      continue
                  self.counter = 0
                  level = float(value)
                  self.level_history.append(level)
                  self.level_history = self.level_history[-60:]
                  if len(self.level_history) < 10:
                      continue
                  lo, hi = min(self.level_history), max(self.level_history)
                  if hi - lo < 0.02:
                      continue
                  threshold = (lo + hi) / 2.0
                  self.raw_symbols.append('1' if level > threshold else '0')
                  self.raw_symbols = self.raw_symbols[-400:]
                  bitstream = self._reconstruct_bits()
                  text = self._decode(bitstream)
                  if text and text != self.last_text:
                      self.message_port_pub(pmt.intern("msg"), pmt.intern(text))
                      self.last_text = text
              return len(input_items[0])
    _source_code_mode: '0'
    comment: Décodage OOK avec échantillonnage x5 et reconstruction des paliers
    num_inputs: '1'
    num_outputs: '0'
    samp_rate: samp_rate
    bit_duration: '0.300'
    type: float
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    type: string
    value: En attente du message OOK…
    label: Message décodé
    is_pair: 'False'
    gui_hint: '[0, 2, 1, 2]'
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_moving_average_xx_0, '0', epy_block_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [epy_block_0, msg, qtgui_edit_box_msg_0, val]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
